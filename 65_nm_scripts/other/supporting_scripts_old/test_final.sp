R2_14 input_dec_1__2 input_dec_1__3 4.000000
R3_14 input_dec_1__3 input_dec_1__4 4.000000
R4_14 input_dec_1__4 input_dec_1__5 4.000000
R5_14 input_dec_1_ input_dec_1__5 19.008000

Xclk__L1_I0 clk__L1_I0:Z clk__L1_I0:A gnd gnds vdd vdds HS65_GS_BFX284
Xindecoder_reg_2_ indecoder_reg_2_:Q indecoder_reg_2_:D indecoder_reg_2_:CP gnd gnds vdd vdds HS65_GS_DFPQX4
Xindecoder_reg_1_ indecoder_reg_1_:Q indecoder_reg_1_:D indecoder_reg_1_:CP gnd gnds vdd vdds HS65_GS_DFPQX4
Xindecoder_reg_0_ indecoder_reg_0_:Q indecoder_reg_0_:D indecoder_reg_0_:CP gnd gnds vdd vdds HS65_GS_DFPQX4
Xoutdecoder_reg_7_ outdecoder_reg_7_:Q outdecoder_reg_7_:D outdecoder_reg_7_:CP gnd gnds vdd vdds HS65_GS_DFPQX4
Xoutdecoder_reg_6_ outdecoder_reg_6_:Q outdecoder_reg_6_:D outdecoder_reg_6_:CP gnd gnds vdd vdds HS65_GS_DFPQX4
Xoutdecoder_reg_5_ outdecoder_reg_5_:Q outdecoder_reg_5_:D outdecoder_reg_5_:CP gnd gnds vdd vdds HS65_GS_DFPQX4
Xoutdecoder_reg_4_ outdecoder_reg_4_:Q outdecoder_reg_4_:D outdecoder_reg_4_:CP gnd gnds vdd vdds HS65_GS_DFPQX4
Xoutdecoder_reg_3_ outdecoder_reg_3_:Q outdecoder_reg_3_:D outdecoder_reg_3_:CP gnd gnds vdd vdds HS65_GS_DFPQX4
Xoutdecoder_reg_2_ outdecoder_reg_2_:Q outdecoder_reg_2_:D outdecoder_reg_2_:CP gnd gnds vdd vdds HS65_GS_DFPQX4
Xoutdecoder_reg_1_ outdecoder_reg_1_:Q outdecoder_reg_1_:D outdecoder_reg_1_:CP gnd gnds vdd vdds HS65_GS_DFPQX4
Xoutdecoder_reg_0_ outdecoder_reg_0_:Q outdecoder_reg_0_:D outdecoder_reg_0_:CP gnd gnds vdd vdds HS65_GS_DFPQX4
